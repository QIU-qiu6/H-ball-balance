# Keil uVision project gimbal_dual.uvprojx, settings and files
target gimbal_dual (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gimbal_dual +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\USER;.\HARDWARE\uart1_ttl;.\HARDWARE\uart3_ttl;.\HARDWARE\estop;.\HARDWARE\oled;.\SYSTEM\delay;.\SYSTEM\sys;.\PROTOCOL\zdt_proto;.\PROTOCOL\k230_proto;.\CONTROL\motor;.\CONTROL\gimbal;.\CONTROL\pid;.;..\ARM\CMSIS\4.2.0\CMSIS\Include;..\ARM\Pack\Keil.STM32F1xx_DFP.2.2.0\Device\Include;..\ARM\Pack\Keil.STM32F1xx_DFP.2.2.0\Device\StdPeriph_Driver\inc
  asm define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c
    ../ARM/Pack/Keil.STM32F1xx_DFP.2.2.0/Device/Source/: system_stm32f10x.c
  group HARDWARE
    ./HARDWARE/uart1_ttl/: uart1_ttl.c
    ./HARDWARE/uart3_ttl/: uart3_ttl.c
    ./HARDWARE/estop/: estop.c
    ./HARDWARE/oled/: oled.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
  group PROTOCOL
    ./PROTOCOL/zdt_proto/: zdt_proto.c
    ./PROTOCOL/k230_proto/: k230_proto.c
  group CONTROL
    ./CONTROL/motor/: motor.c
    ./CONTROL/gimbal/: gimbal_reference.c
    ./CONTROL/pid/: pid.c
  group CORE
    ../ARM/Pack/Keil.STM32F1xx_DFP.2.2.0/Device/Source/ARM/: startup_stm32f10x_md.s
  group FWlib
    ../ARM/Pack/Keil.STM32F1xx_DFP.2.2.0/Device/StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
